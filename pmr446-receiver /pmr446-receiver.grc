options:
  parameters:
    author: Jean-François Auger
    comment: A simple PMR446 receiver with a channels selection
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: PMR446 receiver
  states: {}

blocks:
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Static center frequency, slightly offsetted
      from the PMR446 band
    value: 446.2E6
  states: {}
- name: chan_freq_base
  id: variable
  parameters:
    value: 446.00625E6
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 12.5E3
  states: {}
- name: pmr_channel
  id: variable_qtgui_chooser
  parameters:
    label: PMR Channel
    labels: '[]'
    num_opts: '0'
    options: '[0, 1, 2,3,4,5,6,7,8]'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      The sampling frequency is set to
      1.2MS/s + a little extra in order to "synch"
      the RF recevier clock with the DAC.
      By speeding up the RF sampling we can
      avoid audio underruns (uA).
      This value must be tuned for different hw.
    value: 1.2E6 + samp_rate_compensation
  states: {}
- name: samp_rate_compensation
  id: variable
  parameters:
    value: 15E3
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48E3)
    comment: PMR446 uses NBFM modulation
    max_dev: 5e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: '-65'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - (chan_freq_base + (pmr_channel - 1)*chan_width)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: mixer
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5E3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    norm_window: 'True'
    tr_level: '-60'
    type: complex
    ymin: '-100'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
