options:
  parameters:
    author: Jean-François Auger
    description: A simple FM radio receiver used to listen to FM radio stations.
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: A simple FM radio receiver
  states: {}

blocks:
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '100'
    stop: '1'
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: channel_freq + center_freq_offset
  states: {}
- name: center_freq_offset
  id: variable
  parameters:
    value: 400E3
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 200E3
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 104.7E6
  states: {}
- name: decimation_factor
  id: variable
  parameters:
    value: int(samp_rate / chan_width)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2E6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480E3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75E3
    decim: decimation_factor
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25E3
    win: window.WIN_RECTANGULAR
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    rate: '15'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    rate: '15'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
