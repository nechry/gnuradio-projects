options:
  parameters:
    author: Jean-François Auger
    category: Custom
    description: Sniffing nRF24 with HackRF
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: nRF24 demodulator to sniff BLEA packets
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9 + (nrf_channel*1e6)
  states: {}
- name: fifo_file_path
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: /tmp/fifo
    writeback: None
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 170e3
  states: {}
- name: nrf_channel
  id: variable
  parameters:
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(4*2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: fifo_file_path
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.9e6
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '2048'
    name: '"Scope Plot"'
    type: float
    ymin: '-120'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_short_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
